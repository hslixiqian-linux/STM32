# Keil uVision project IAP.uvprojx, settings and files
target CODE (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IAP +hex
  AfterMake: fromelf.exe --bin -o "%L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\StdPeriphDriver\inc;.\User\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./CMSIS/: system_stm32f10x.c core_cm3.c
    ./StdPeriphDriver/src/: stm32f10x_exti.c
  group StdPeriphDriver
    ./StdPeriphDriver/src/: misc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c
  group StartUp
    ./StartUp/: startup_stm32f10x_hd.s
  group User
    ./User/Src/: main.c flash.c uart.c update.c delay.c stm32f10x_it.c
